# Keil uVision project lab5.uvprojx, settings and files
target lab5 (6220000::V6.22::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab5
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group src
    ./src/: main.c fsm_main.c i2cFram.c keypad.c messages.c timers.c uart.c fsm_tm.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube LL:COMMON 1.11.3, Device:STM32Cube LL:DMA 1.11.3, Device:STM32Cube LL:GPIO 1.11.3, Device:STM32Cube LL:I2C 1.11.3, Device:STM32Cube LL:PWR 1.11.3, Device:STM32Cube LL:RCC 1.11.3, Device:STM32Cube LL:USART 1.11.3, Device:STM32Cube LL:UTILS 1.11.3, Device:Startup 1.11.3
